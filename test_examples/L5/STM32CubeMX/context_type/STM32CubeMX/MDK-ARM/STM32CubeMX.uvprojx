# Keil uVision project STM32CubeMX.uvprojx, settings and files
target STM32CubeMX (6140001::V6.14.1::ARMCLANG)
  device: STM32L562QEIxQ STMicroelectronics
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: STM32CubeMX +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L562xx
  c include: ../Inc;C:/Users/davles01/STM32Cube/Repository/STM32Cube_FW_L5_V1.5.0/Drivers/STM32L5xx_HAL_Driver/Inc;C:/Users/davles01/STM32Cube/Repository/STM32Cube_FW_L5_V1.5.0/Drivers/STM32L5xx_HAL_Driver/Inc/Legacy;C:/Users/davles01/STM32Cube/Repository/STM32Cube_FW_L5_V1.5.0/Drivers/CMSIS/Device/ST/STM32L5xx/Include;C:/Users/davles01/STM32Cube/Repository/STM32Cube_FW_L5_V1.5.0/Drivers/CMSIS/Include
  scatter file: stm32l562xe_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32l562xx.s
  group Application/User
    ../Src/: main.c stm32l5xx_it.c stm32l5xx_hal_msp.c
  group Drivers/STM32L5xx_HAL_Driver
    C:/Users/davles01/STM32Cube/Repository/STM32Cube_FW_L5_V1.5.0/Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal_fdcan.c stm32l5xx_hal.c stm32l5xx_hal_i2c.c stm32l5xx_hal_i2c_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_flash_ramfunc.c stm32l5xx_hal_gpio.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_cortex.c stm32l5xx_hal_icache.c stm32l5xx_hal_uart.c stm32l5xx_hal_uart_ex.c stm32l5xx_ll_sdmmc.c stm32l5xx_hal_sd.c stm32l5xx_hal_sd_ex.c stm32l5xx_hal_spi.c stm32l5xx_hal_spi_ex.c stm32l5xx_hal_tim.c stm32l5xx_hal_tim_ex.c stm32l5xx_hal_pcd.c stm32l5xx_hal_pcd_ex.c stm32l5xx_ll_usb.c
  group Drivers/CMSIS
    ../Src/: system_stm32l5xx.c
software components: CMSIS:CORE 4.3.0
