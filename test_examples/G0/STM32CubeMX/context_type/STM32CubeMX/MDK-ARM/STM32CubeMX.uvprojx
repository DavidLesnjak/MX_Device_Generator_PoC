# Keil uVision project STM32CubeMX.uvprojx, settings and files
target STM32CubeMX (ARM-ADS)
  device: STM32G070RBTx STMicroelectronics
  cpu: IRAM(0x20000000-0x20008FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: STM32CubeMX +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G070xx
  c include: ../Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include
  group Application/MDK-ARM
    ./: startup_stm32g070xx.s
  group Application/User
    ../Src/: main.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_ll_dma.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_usart.c stm32g0xx_hal_usart_ex.c stm32g0xx_hal_irda.c
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
software components: CMSIS:CORE 4.3.0
