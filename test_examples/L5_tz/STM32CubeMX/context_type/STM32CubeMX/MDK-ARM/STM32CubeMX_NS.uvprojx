# Keil uVision project STM32CubeMX_NS.uvprojx, settings and files
target STM32CubeMX_NS (6140001::V6.14.1::ARMCLANG)
  device: STM32L562QEIxQ STMicroelectronics
  cpu: IRAM(0x20018000-0x2002FFFF) IROM(0x8040000-0x807FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: STM32CubeMX_NS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L562xx
  c include: ../NonSecure/Inc;../Secure_nsclib;../Drivers/STM32L5xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32L5xx/Include;../Drivers/STM32L5xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include
  scatter file: stm32l562xe_flash_ns.sct
  link misc: ../Secure_nsclib/secure_nsclib.o
  group Application/MDK-ARM
    ./: startup_stm32l562xx.s
  group Application/User/NonSecure
    ../NonSecure/Src/: main.c stm32l5xx_it.c stm32l5xx_hal_msp.c
  group Drivers/STM32L5xx_HAL_Driver
    ../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_i2c.c stm32l5xx_hal_i2c_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_flash_ramfunc.c stm32l5xx_hal_gpio.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_cortex.c stm32l5xx_hal_icache.c stm32l5xx_hal_tim.c stm32l5xx_hal_tim_ex.c stm32l5xx_hal_uart.c stm32l5xx_hal_uart_ex.c stm32l5xx_ll_sdmmc.c stm32l5xx_hal_sd.c stm32l5xx_hal_sd_ex.c
  group Drivers/CMSIS
    ../NonSecure/Src/: system_stm32l5xx_ns.c
software components: CMSIS:CORE 4.3.0
