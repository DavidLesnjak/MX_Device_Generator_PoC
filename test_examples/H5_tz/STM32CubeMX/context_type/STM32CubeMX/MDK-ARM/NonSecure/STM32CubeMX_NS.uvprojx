# Keil uVision project STM32CubeMX_NS.uvprojx, settings and files
target STM32CubeMX_NS (6140001::V6.14.1::ARMCLANG)
  device: STM32H573IIKx STMicroelectronics
  cpu: IRAM(0x20050000-0x2009FFFF) IROM(0x08100000-0x81FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: STM32CubeMX_NS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H573xx
  c include: ../../NonSecure/Inc;../../Secure_nsclib;../../Drivers/STM32H5xx_HAL_Driver/Inc;../../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy;../../Drivers/CMSIS/Include
  link misc: ../../Secure_nsclib/secure_nsclib.o
  group Application/MDK-ARM
    ../: startup_stm32h573xx.s
  group Application/User/NonSecure
    ../../NonSecure/Src/: main.c stm32h5xx_it.c stm32h5xx_hal_msp.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_cortex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal.c stm32h5xx_hal_exti.c stm32h5xx_hal_i2c.c stm32h5xx_hal_i2c_ex.c stm32h5xx_ll_sdmmc.c stm32h5xx_ll_dlyb.c stm32h5xx_hal_sd.c stm32h5xx_hal_sd_ex.c stm32h5xx_hal_spi.c stm32h5xx_hal_spi_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c stm32h5xx_hal_fdcan.c
  group Drivers/CMSIS
    ../../NonSecure/Src/: system_stm32h5xx_ns.c
software components: CMSIS:CORE 4.3.0
